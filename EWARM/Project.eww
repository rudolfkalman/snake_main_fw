<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\main_module.ewp</path>
  </project>
  <batchBuild />
</workspace>
